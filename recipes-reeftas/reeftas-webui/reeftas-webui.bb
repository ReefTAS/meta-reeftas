require reeftas-webui.inc

SRCREV = "7fc3382343de9b193f1fe0391b23c7f36a497bea"
SRC_URI[md5sum] = "291469e87ab68614e2f08932418ecace"
SRC_URI[sha256sum] = "4f342109194cd3f791ac452ffec8f6990382e72339069f58f8fcacb78e7a04dc"



